**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*             Version 0.9.98 Alpha (14/10/2009)              *
**************************************************************

* Schematic : /home/lroot/Desktop/sedra-spice/ex2.2.1/invert.sch

* Component Definitions
Eopamp 1 0 0 2 1e6
R1 3 2 1k
R2 2 1 10k
Vi 3 0 DC 1V

* NG-Spice Simulation Commands
.TF V(1) Vi

.END
